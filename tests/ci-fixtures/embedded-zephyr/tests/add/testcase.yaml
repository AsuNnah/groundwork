## tests/ci-fixtures/embedded-zephyr/tests/add/testcase.yaml
```yaml
tests:
  fixture.add:
    platform_allow:
      - native_sim
    integration_platforms:
      - native_sim
    tags: fixture
```
